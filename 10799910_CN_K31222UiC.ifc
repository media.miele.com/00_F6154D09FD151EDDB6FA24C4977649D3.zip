Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-04-11T08:32:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 11 08:32:02 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\64887489-faff-45f9-a1fb-7ca8fea81179\eee2f6cb-b81f-4011-ac34-fa0364e58609\ifc * Database version: 5507 * Database creation date: Tue Apr 11 08:32:01 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 11 08:32:01 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 11 08:32:01 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10799910_CN_K31222UiC:36312221_CN_10799910_K31222UiC, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 36312221_CN_10799910_K31222UiC
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 36312221_CN_10799910_K31222UiC
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 820 mm; Depth: 550 mm
Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_BRWS, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
